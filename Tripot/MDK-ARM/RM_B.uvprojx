# Keil uVision project RM_B.uvprojx, settings and files
target RM_B (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x800FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: RM_B +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\top\Inc;..\middle\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Application/User
    ../Src/: main.c can.c dma.c gpio.c tim.c stm32f1xx_it.c usart.c stm32f1xx_hal_msp.c
  group top
    ../top/Src/: robodata.c t_monitor.c tim_callback.c tripod.c strike.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group middle
    ../middle/Src/: can_callback.c dji_Protocol.c gpio_callback.c m_imu.c m_moto.c m_remote.c m_transmit.c moto_encoder.c pid.c tx2_Protocol.c usart_callback.c hwt901b.c queue.c
  group DOC
    ../Doc/: version.txt
software components: CMSIS:CORE 4.3.0
